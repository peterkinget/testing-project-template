v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {title.sym} -647.5 1095 0 0 {name=l2 author="Peter Kinget"}
